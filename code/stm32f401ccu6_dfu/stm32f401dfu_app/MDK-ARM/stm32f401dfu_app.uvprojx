# Keil uVision project stm32f401dfu_app.uvprojx, settings and files
target stm32f401dfu_app (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f401dfu_app +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ./stm32f401dfu_app/@L.bin  ./stm32f401dfu_app/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F401xC,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,USE_HAL_DRIVER,STM32F401xC
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP\SSD1306_IIC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: main.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/BSP
    ../BSP/SSD1306_IIC/: SSD1306_IIC.c
  group STSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
software components: CMSIS:CORE 4.3.0
