# Keil uVision project stm32f401_template_Pro.uvprojx, settings and files
target stm32f401_template_Pro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f401_template_Pro +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,USE_HAL_DRIVER,STM32F401xC
  c include: ../Inc;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Drivers/STM32F4xx_HAL_Driver/Inc;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Drivers/CMSIS/Device/ST/STM32F4xx/Include;E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Drivers/CMSIS/Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\SSD1306_IIC;..\BSP\WS2812B\inc;..\BSP\MPU6050;..\BSP\OLED_0.96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group BSP
    ../BSP/SSD1306_IIC/: SSD1306_IIC.c
    ../BSP/WS2812B/src/: ws2812b.c Adafruit_NeoPixel.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/OLED_0.96/: softi2c.c Task_oled.c
  group Application/User
    ../Src/: main.c gpio.c dma.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    E:/STMicroelectronics/STM32Cube/STM32Cube_FW_F4_V1.24.2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
